# Keil uVision project project.uvprojx, settings and files
target rt-thread (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: N32H785xIx7:CM7 Nationstech
  pack: Nationstech.N32H7xx_DFP.1.2.0
  cpu: IRAM(0x24000000,0x20000) IROM(0x15000000,0x001E0000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: rt-thread +hex
  AfterMake: fromelf --bin !L --output rtthread.bin
  c flags: Optim=1 OneElfS=1 uC99=1
  c define: USE_STDPERIPH_DRIVER, __ICACHE_PRESENT=1, __DCACHE_PRESENT=1, CORE_CM7, __RTTHREAD__, RT_USING_LIBC, USING_TCM, __CLK_TCK=RT_TICK_PER_SECOND, __STDC_LIMIT_MACROS, RT_USING_ARMLIBC, N32H76x
  c include: .;packages/CMSIS-Core-latest/Include;../libraries/n32h7xx_cmsis_driver-latest/device;../libraries/n32h7xx_std_driver-latest/n32h7xx_std_periph_driver/inc;applications;board;board/Cube_Config/USER/inc;board/ports;../../../../include;../../../../libcpu/arm/common;../../../../libcpu/arm/cortex-m7;../../../../components/net/utest;../../../../components/libc/compilers/common/include;../../../../components/libc/compilers/common/extension;../../../../components/libc/compilers/common/extension/fcntl/octal;../../../../components/libc/posix/ipc;../../../../components/libc/posix/io/poll;../../../../components/libc/posix/io/eventfd;../../../../components/libc/posix/io/epoll;../../../../components/drivers/include;../../../../components/drivers/smp_call;../../../../components/finsh;../../../../components/dfs/dfs_v1/include;../../../../components/dfs/dfs_v1/filesystems/devfs;../libraries/N32_Drivers/drivers;../libraries/N32_Drivers/drivers/config;../libraries/N32_Drivers;..\..\..\RTT
  library: MicroLIB
  memory RVCT4: ROM 0x15000000 size 0x1e0000
  memory RVCT9: RAM 0x24000000 size 0x20000
  scatter file: .\board\linker_scripts\link.sct
  link misc: --entry Reset_Handler
--keep=*(.rti_fn.*)
  group Applications
    applications/: main.c
  group CPU
    ../../../../libcpu/arm/common/: atomic_arm.c div0.c showmem.c
    ../../../../libcpu/arm/cortex-m7/: context_rvds.S cpu_cache.c cpuport.c
  group DeviceDrivers
    ../../../../components/drivers/core/: device.c
    ../../../../components/drivers/ipc/: completion_comm.c completion_up.c condvar.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
    ../../../../components/drivers/pin/: dev_pin.c
    ../../../../components/drivers/serial/: dev_serial.c
    ../../../../components/drivers/adc/: adc.c
  group Drivers
    ../libraries/N32_Drivers/drivers/: drv_gpio.c drv_usart.c drv_adc.c
    ../libraries/N32_Drivers/: drv_common.c
    board/Cube_Config/USER/src/: n32h7xx_cfg.c
    board/: board.c
  group Filesystem
    ../../../../components/dfs/dfs_v1/filesystems/devfs/: devfs.c
    ../../../../components/dfs/dfs_v1/src/: dfs.c dfs_file.c dfs_fs.c dfs_posix.c
  group Finsh
    ../../../../components/finsh/: shell.c msh.c msh_parse.c cmd.c msh_file.c
  group RTT
    ../../../RTT/: SEGGER_RTT.c SEGGER_RTT_printf.c
  group Kernel
    ../../../../src/: clock.c components.c cpu_up.c defunct.c idle.c ipc.c irq.c kservice.c mem.c mempool.c object.c scheduler_comm.c scheduler_up.c thread.c timer.c
  group Libc
    ../../../../components/libc/compilers/armlibc/: syscall_mem.c syscalls.c
    ../../../../components/libc/compilers/common/: cctype.c cstdlib.c cstring.c ctime.c cunistd.c cwchar.c
    ../../../../src/klibc/: kerrno.c kstdio.c kstring.c rt_vsnprintf_tiny.c rt_vsscanf.c
  group Libraries
    ../libraries/n32h7xx_std_driver-latest/n32h7xx_std_periph_driver/src/: misc.c n32h7xx_gpio.c n32h7xx_mmu.c n32h7xx_dma.c n32h7xx_dmamux.c n32h7xx_pwr.c n32h7xx_rcc.c n32h7xx_dbg.c n32h7xx_exti.c n32h7xx_usart.c n32h7xx_adc.c
  group Libraries-CMSIS
    ../libraries/n32h7xx_cmsis_driver-latest/device/: system_n32h7xx.c soc_mdk.c
    ../libraries/n32h7xx_cmsis_driver-latest/device/startup/: startup_n32h73x_76x.s
